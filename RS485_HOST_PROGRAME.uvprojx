# Keil uVision project RS485_HOST_PROGRAME.uvprojx, settings and files
target Project (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RS485_HOST_PROGRAME +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\STM32F10x_FWLib\inc;.\HARDWARE\CRC16;.\HARDWARE\RS485;.\HARDWARE\TIMER;.\HARDWARE\LED;.\HARDWARE\KEY;.\DEMO;.\HARDWARE\WIFI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HAREWARD
    ./HARDWARE/LED/: led.c
    ./HARDWARE/RS485/: rs485.c
    ./HARDWARE/CRC16/: crc16.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/WIFI/: wifi.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group CODE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ./STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group Demo
    ./DEMO/: demo.c
